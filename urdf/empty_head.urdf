Commit message: Added content to link head

File: urdf/empty_head.urdf (robot description, URDF)
Before this commit: robot empty, 1 links, 0 joints
Links:
- link head: mass None -> 1.41984; geometry collision box size=0.0468 0.12 0.1184; collision box size=0.1311 0.12 0.0591
